PACKAGECONFIG_append = " networkd resolved"
RDEPENDS:${PN}:append = " wpa-supplicant"
